# Keil uVision project Project.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App;.\App\Modules;.\App\Modules\Light_Control;.\Lib;.\Lib\Drivers;.\Lib\HAL;.\Lib\STC8H_Lib
  group APP
    ./App/: main.c
  group App/Modules/Light_Control
    ./App/Modules/Light_Control/: light_control.c light_control.h
  group Lib/STC8H_Lib
    ./Lib/STC8H_Lib/: Config.h STC8G_H_ADC.c STC8G_H_ADC.h STC8G_H_Delay.c STC8G_H_Delay.h STC8G_H_GPIO.c STC8G_H_GPIO.h STC8G_H_NVIC.c STC8G_H_NVIC.h STC8G_H_Switch.h STC8G_H_UART.c STC8G_H_UART.h STC8G_H_UART_Isr.c STC8H.h STC8H_PWM.c STC8H_PWM.h Type_def.h
  group Lib/HAL
    ./Lib/HAL/: hal_light.h
  group Lib/Drivers
    ./Lib/Drivers/: stc8h_light.c
